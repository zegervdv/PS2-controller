# Keil uVision project STM32F072B-Discovery_Demo.uvproj, settings and files
target STM32F072B-Discovery_Demo (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_DEVICE_FS,STM32F072,INTERNAL_PULLUP,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STMTouch_Driver\inc;..\..\..\Utilities\STM32F072B-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/Source/Templates/arm/: startup_stm32f072.s
  group STM32F072B_DISCOVERY
    ../../../Utilities/STM32F072B-Discovery/: stm32f072b_discovery.c stm32f072b_discovery_l3gd20.c
  group STM32F0xx_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM32_USB_Device_Driver
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library/Class/HID
    ../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group STM32_USB_Device_Library/Core
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STMTouch_Driver
    ../../../Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32f0xx.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32f0xx.c tsl_touchkey.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c tsl_user.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
