<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F072B-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_DMA\EWARM\ADC_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\CRC_8BitsCRCMessage\EWARM\CRC_8BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\CRC_32BitsCRCMessage\EWARM\CRC_32BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DAC_SignalGenerations\EWARM\DAC_SignalGenerations.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FlashToRamTransfer\EWARM\DMA_FlashToRamTransfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EEPROM_Example\EWARM\EEPROM_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI_Example\EWARM\EXTI_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\FLASH_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\GPIO_IOToggle\EWARM\GPIO_IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Reset\EWARM\IWDG_Reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_WindowMode\EWARM\IWDG_WindowMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC_Example\EWARM\RCC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\SysTick_Example\EWARM\SysTick_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWMInput\EWARM\TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\USB_Example\EWARM\USB_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\WWDG_Example\EWARM\WWDG_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Template\EWARM\Template.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>hh</name>
      <member>
        <project>ADC_DMA</project>
        <configuration>ADC_DMA</configuration>
      </member>
      <member>
        <project>CRC_32BitsCRCMessage</project>
        <configuration>CRC_32BitsCRCMessage</configuration>
      </member>
      <member>
        <project>CRC_8BitsCRCMessage</project>
        <configuration>CRC_8BitsCRCMessage</configuration>
      </member>
      <member>
        <project>DAC_SignalGenerations</project>
        <configuration>DAC_SignalGenerations</configuration>
      </member>
      <member>
        <project>DMA_FlashToRamTransfer</project>
        <configuration>DMA_FlashToRamTransfer</configuration>
      </member>
      <member>
        <project>EEPROM_Example</project>
        <configuration>EEPROM_Example</configuration>
      </member>
      <member>
        <project>EXTI_Example</project>
        <configuration>EXTI_Example</configuration>
      </member>
      <member>
        <project>FLASH_Program</project>
        <configuration>FLASH_Program</configuration>
      </member>
      <member>
        <project>GPIO_IOToggle</project>
        <configuration>GPIO_IOToggle</configuration>
      </member>
      <member>
        <project>IWDG_Reset</project>
        <configuration>IWDG_Reset</configuration>
      </member>
      <member>
        <project>IWDG_WindowMode</project>
        <configuration>IWDG_WindowMode</configuration>
      </member>
      <member>
        <project>PWR_CurrentConsumption</project>
        <configuration>PWR_CurrentConsumption</configuration>
      </member>
      <member>
        <project>RCC_Example</project>
        <configuration>RCC_Example</configuration>
      </member>
      <member>
        <project>STM32F072B-Discovery_Demo</project>
        <configuration>STM32F072B-Discovery_Demo</configuration>
      </member>
      <member>
        <project>SysTick_Example</project>
        <configuration>SysTick_Example</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>TIM_PWMInput</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>TIM_TimeBase</configuration>
      </member>
      <member>
        <project>WWDG_Example</project>
        <configuration>WWDG_Example</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


