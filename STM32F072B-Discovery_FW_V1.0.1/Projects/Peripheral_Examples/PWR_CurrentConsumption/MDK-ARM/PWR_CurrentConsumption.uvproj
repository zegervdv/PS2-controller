# Keil uVision project PWR_CurrentConsumption.uvproj, settings and files
target PWR_CurrentConsumption (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: PWR_CurrentConsumption
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,
  c misc: --C99
  c include: ..\;..\..\..\..\Libraries\CMSIS\Device\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F072B-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/Source/Templates/arm/: startup_stm32f072.s
  group STM32F072B_DISCOVERY
    ../../../../Utilities/STM32F072B-Discovery/: stm32f072b_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c
  group User
    ../: main.c stm32f0xx_it.c stm32f0xx_lp_modes.c system_stm32f0xx.c
